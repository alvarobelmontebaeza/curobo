Commit message: minor repairs

File: src/curobo/content/assets/robot/widowx/widowGo1_simple.urdf (robot description, URDF)
Before this commit: robot widowGo1, 40 links, 39 joints
Joints:
- joint floating_base: origin xyz=0 0 0.45 rpy=0 0 0.0 -> xyz=0 0 0.4 rpy=0 0 0.0
