Commit message: Improve arm's base position

File: src/curobo/content/assets/robot/sagittarius/K1Go1.urdf (robot description, URDF)
Before this commit: robot K1Go1, 37 links, 36 joints
Joints:
- joint K1_mount: origin xyz=0 0 0 rpy=0 0 0.07 -> xyz=0 0 0.055 rpy=0 0 0
